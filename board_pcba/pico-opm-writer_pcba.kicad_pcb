# Repository hyano/pico-opm-writer

File README.md (part):

# pico-opm-writer

Raspberry Pi Pico 2 (RP2350) を YM2151 (OPM) に直結して鳴らすためのファームウェア。
ホスト PC から USB シリアルで**レジスタを直接叩く**ことも、内蔵フラッシュに入れた
**VGM / MDX を Pico 単体で演奏する**こともできる。鳴った音は YM3012 (DAC) から PCM として
取り込むので、**USB 経由の録音**と **I2S DAC からのアナログ出力**が外部の機材なしで
同時に得られる。

- **レジスタ書き込み**: USB CDC (仮想 COM ポート) にテキストコマンドを打つだけでよく、
  `screen` や `minicom` のような素のターミナルで足りる（[§3](#3-ホストインタフェース)）。
  バッチ実行やキャプチャの自動化には [ホスト側ツール](#10-ホスト側ツール)（`tools/`）を使う
- **VGM 再生**: `/VGM/` に置いた `.vgm` / `.vgz` を、ホストからシーケンスを流し込まずに
  再生する。ファイルが申告するクロックへ φM を自動で合わせる（[§8](#8-vgm-再生)）
- **MDX 再生**: `/MDX/` に置いた X68000 の MDX を、MXDRV 相当の音源ドライバで
  FM 8ch + ADPCM 8ch 再生する。ADPCM (PDX) はソフトウェアでデコードして FM に混ぜる
  （[§9](#9-mdx-再生)）
- **曲データの受け渡し**: 内蔵フラッシュ 4MiB の一部を FAT にしてあり、USB マスストレージ
  として PC から見える。SD カードも外付けフラッシュも要らない（[§7](#7-ストレージ)）
- **PCM 出力**: YM3012 の出力を 2 本目の USB CDC から PCM で吸い出せる（[§4](#4-pcm-出力)）。
  同じデータを I2S で PCM5102A へ常時流している（[§5](#5-i2s-出力)）。ロジックアナライザや
  外部の録音機材は要らない
- **PC を繋がない運用**: ボタン 3 個で自動連続再生とストレージの切り替えができる
  （[§3.17](#317-autoplay自動再生) / [§3.20](#320-ボタンgp21--gp22)）

ファームウェアの内部設計と実装は [docs/pico-opm-writer.md](docs/pico-opm-writer.md) にある。

## 1. ハードウェア構成

### 1.1 接続表

Pico 2 は OPM のバスへ双方向に接続する。**データバスを駆動するのは通常 Pico 側だけ**で、
読み出し（[`r`](#321-r読み出し)）の実行中だけ Pico 側を入力へ倒して OPM に駆動させる。
これとは別に、YM3012 (DAC) のシリアル出力を Pico 側へ取り込む（[§4](#4-pcm-出力)）。

| Pico 2 GPIO | 物理ピン | 接続先 | 方向 | 備考 |
| --- | --- | --- | --- | --- |
| GP0  | 1  | -    | -   | 将来のデバッグ UART TX 用に予約 |
| GP1  | 2  | -    | -   | 将来のデバッグ UART RX 用に予約 |
| GP2  | 4  | D0   | I/O | データバス。通常は出力、読み出し中だけ入力 |
| GP3  | 5  | D1   | I/O | |
| GP4  | 6  | D2   | I/O | |
| GP5  | 7  | D3   | I/O | |
| GP6  | 9  | D4   | I/O | |
| GP7  | 10 | D5   | I/O | |
| GP8  | 11 | D6   | I/O | |
| GP9  | 12 | D7   | I/O | D0-D7 は連続した GPIO であること（マスクでまとめて読み書きするため） |
| GP10 | 14 | A0   | OUT | L=アドレスラッチ / H=データ書き込み |
| GP11 | 15 | /CS  | OUT | チップセレクト（負論理） |
| GP12 | 16 | /WR  | OUT | 書き込みストローブ（負論理） |
| GP13 | 17 | /RD  | OUT | 読み出しストローブ（負論理）。[`r`](#321-r読み出し) の実行中だけ L |
| GP14 | 19 | /IC  | OUT | ハードウェアリセット（負論理） |
| GP15 | 20 | φM   | OUT | マスタークロック、PIO で生成 |
| GP16 | 21 | /IRQ | IN  | 割り込み要求（負論理）。プルアップ、レベル参照のみ |
| GP17 | 22 | SO   | IN  | YM3012 シリアルデータ。PIO の in_base |
| GP18 | 24 | φ1   | IN  | YM3012 ビットクロック（φM/2） |
| GP19 | 25 | SH1  | IN  | CH2 のサンプルホールド。フレーム同期に使う |
| GP20 | 26 | SH2  | IN  | CH1 のサンプルホールド。現在は未使用 |
| GP21 | 27 | SW1  | IN  | ボタン 1（[§3.20](#320-ボタンgp21--gp22)）。内部プルアップ、押下で GND |
| GP22 | 29 | SW2  | IN  | ボタン 2（同上） |
| GP25 | -  | -    | OUT | 基板上 LED（[§3.9](#39-led)）。`PICO_DEFAULT_LED_PIN` |
| GP26 | 31 | BCK  | OUT | I2S ビットクロック（[§5](#5-i2s-出力)） |
| GP27 | 32 | LRCK | OUT | I2S ワードセレクト。BCK の次の GPIO であること |
| GP28 | 34 | DIN  | OUT | I2S データ |
| RUN  | 30 | SW3  | IN  | Pico 2 のリセット端子。押下で GND に落としてリセット。**ファームウェアからは見えない**（[§3.20](#320-ボタンgp21--gp22)） |
| GND  | 3, 8, 13, 18 … | GND | - | OPM と共通グラウンドを取ること |

GP23 / GP24 は Pico 2 の内部用途（`PICO_SMPS_MODE_PIN` / `PICO_VBUS_PIN`）なので使わない。
I2S の MCLK は使わないので、DAC へ出すのは GP26-GP28 の 3 本だけ。

SO / φ1 / SH1 / SH2 は **GP17 から連続していること**。キャプチャ用の PIO がこの 4 本を
in_base からのオフセットで参照する（[docs §4.2](docs/pico-opm-writer.md#42-pio-によるビット取り込み)）。

ピン番号の定義は [opm.h](src/opm.h) の `OPM_PIN_*`、[ym3012.h](src/ym3012.h) の `YM3012_PIN_*`、
[button.h](src/button.h) の `BUTTON_PIN_*` にまとまっている。

### 1.2 GPIO を割り当てない OPM 端子

| OPM 端子 | 処理 | 理由 |
| --- | --- | --- |
| CT1 / CT2 | 未接続で可 | 汎用出力端子。本ファームウェアは使わない |

### 1.3 配線上の注意

**Pico 2 と OPM は全線を直結する。** レベル変換器も分圧も挟まない。
[board/](board/) の基板もこの前提で起こしてある。モジュールを使わず RP2350A と PCM5102A を
直接実装する改版が [board_pcba/](board_pcba/README.md) にある（回路図のみ）。

- **入力側（Pico → OPM）**: OPM は 5V デバイス、Pico 2 の GPIO は 3.3V。RP2350 の 3.3V 出力を
  OPM が H / L として判別できることは実機で確認済みで、[test/](test/) の実測データはすべて
  この直結構成で取れている。ただし OPM の入力 H レベル閾値には個体差・ロット差があり、
  他の個体でも同じように動く保証は無い（未確認）。動作しない場合はバッファ / レベルシフタ
  （74HCT244 等）を φM とバス側に挿入する。
- **出力側（OPM → Pico）**: SO / φ1 / SH1 / SH2 / /IRQ は 5V デバイスである OPM の**出力**で、
  H レベルは 3.3V を超える。**RP2350 の GPIO 0-25 は 5V トレラント**なので直結でよい
  （[RP2350 データシート](https://datasheets.raspberrypi.com/rp2350/rp2350-datasheet.pdf)
  §14.8.2.1 Table 1426 の `Digital IO (FT)` / §14.9.1 Table 1433 の `VPIN_FT`）。
  成立の条件は次の 2 つで、本構成はどちらも満たしている。

  | 条件 | 本構成での成立 |
  | --- | --- |
  | 対象は **GPIO 0-25 のみ**（`Digital IO (FT)` パッド）。GP26-GP29 は ADC 兼用の `Digital IO / Analogue` で対象外 | 5V を受けるのは GP2-GP9 (D0-D7) / GP16 (/IRQ) / GP17-GP20 (SO・φ1・SH1・SH2) だけで、すべて範囲内 |
  | 5V が掛かっている間 **IOVDD が 3.3V で給電されている**こと。無給電のまま 5V を掛けるとパッドが壊れる | OPM の 5V は Pico の VBUS から取るので、5V があるときは必ず Pico の 3.3V も生きている |

  **ステッピングによる違いは無い。** データシートの FT パッドの規定は版を区別しておらず、
  Appendix C も A4 を "This stepping has no hardware changes." としている。
  A4 の[告知](https://www.raspberrypi.com/news/rp2350-a4-rp2354-and-a-new-hacking-challenge/)
  （2025-07-29）は認定試験を通したという告知であってシリコンの変更ではないので、
  出回っている A2 の Pico 2 でも同じように使える
  （[Raspberry Pi のエンジニアの明言](https://forums.raspberrypi.com/viewtopic.php?p=2330278)）。

  絶対最大定格は GPIO 0-25 が IOVDD = 3.3V のとき 5.5V、IOVDD = 0V のとき 3.63V
  （Table 1433 の `VPIN_FT`）。それ以外のピンは IOVDD + 0.5V。/IRQ は
  [opm.c](src/opm.c) が内部プルアップを張るので、外付け抵抗は要らない。

  **GP26-GP28（I2S の BCK / LRCK / DIN）に 5V デバイスを繋いではいけない。**
  この 3 本は 5V トレラントの対象外。接続先の PCM5102A は 3.3V ロジックで、
  しかも Pico からの出力専用なので現状は問題にならない（[§5](#5-i2s-出力)）。
- **バスの衝突防止**: D0-D7 は双方向なので、OPM と Pico が同時に駆動すると衝突する。
  /RD を H に保っていれば OPM は D0-D7 を駆動しないため、ファームウェアは
  **読み出し（[`r`](#321-r読み出し)）の実行中以外は /RD を H に固定**している。
  読み出しでは、OPM に駆動させる前に Pico 側を入力へ倒し、/RD を H に戻して OPM が
  バスを手放してから出力へ戻す。この間 D0-D7 は OPM の 5V 出力を受けるので、
  上の表の条件（GPIO 0-25・IOVDD 給電中）がそのまま効く。
  **ただしこれが効くのは GPIO を初期化した後だけ。** RP2350 のパッドはリセット直後
  入力 + プルダウン（`PADS_BANK0_GPIO0_RESET` の `PDE` = 1）なので、電源投入から
  `opm_init()` が /CS と /RD を H にするまでの間は OPM から見て /CS = L / /RD = L となり、
  **OPM が D0-D7 を駆動する窓がある**。この窓では Pico 側がまだ入力なので駆動は衝突せず、
  D0-D7 に乗る 5V も上の表の条件を満たす。窓そのものを塞ぎたければ /CS を 5V へ
  10kΩ 程度でプルアップする（このとき GP11 も 5V を受けるが、GPIO 0-25 なので同じく
  条件の内側）。
- 電源には十分なデカップリング（OPM の VCC-GND 間に 0.1µF + 10µF 程度）を入れる。
- **ボタンは 3 個ともスイッチ 1 個だけでよい。** SW1 / SW2 は GP21 / GP22 と GND の間、
  SW3 は RUN と GND の間に入れる。**外付けのプルアップ抵抗もコンデンサも要らない**
  （GP21 / GP22 は RP2350 の内部プルアップを張って負論理で読み、チャタリングは
  ファームウェア側で時間ベースに除去する。RUN は Pico 2 側で既にプルアップされている）。
  SW1 / SW2 を使わないなら GP21 / GP22 は開放でよい。内部プルアップで「離されている」と
  読めるので、ボタンを実装していない基板でも既定のファームウェアがそのまま動く。

## 2. クロック設定 (φM)

φM は PIO で生成する。φM とシステムクロックは**整数分周（ジッタなし）になる組**でしか
意味を持たないため、両者をペアにしたプリセットとして持たせている。

| プリセット | `clock` の引数 | φM | sys_clk | clkdiv | fs (φM/64) | 備考 |
| --- | --- | --- | --- | --- | --- | --- |
| 4MHz（**起動時の既定**） | `4` | 4.000000 MHz | 144 MHz（= 4MHz × 36） | 18 | 62500.0 Hz | YM2151 の定格上限。RP2350 定格 150MHz 以内 |
| NTSC | `3.58` | 3.579545 MHz | 157.5 MHz（= × 44） | 22 | 55930.4 Hz | NTSC カラーサブキャリア = 315/88 MHz。定格比 約 +5% の OC |

**動作させたまま切り替えられる。**

- `clock 4` / `clock 3.58` で手動切り替え（[§3.16](#316-clockクロック切り替え)）
- `vgm play` はヘッダが申告する YM2151 のクロックへ自動追従する
  （[§8.3](#83-φm-と-vgm-のクロック)）。`clock fixed` で抑止できる
- `mdx play` は X68000 の φM = 4MHz へ寄せる（[§9.3](#93-φm-と-テンポ)）。
  同じく `clock fixed` で抑止できるが、MDX は**テンポも φM に比例して狂う**
- **PCM を流している間は切り替えを拒否する。** サンプリングレートが
  ストリームの途中で変わると、ホスト側で出来上がる WAV の時間軸が黙って狂うため。
  `p 2` の待機中はまだ流していないので通る（[§3.16](#316-clockクロック切り替え)）

切り替えは sys_clk ごと張り替えるが、**φM・BCK・LRCK の H/L 期間が公称値より
短くなることはない**（順序と手順は [docs §2.3](docs/pico-opm-writer.md#23-実行時の切り替え)）。
所要は数百 µs で、その間 I2S のリング（先行 16.4ms）は枯れないのでアンダーランしない。

起動時にどちらで立ち上げるかは次のどちらかで決める。

- `opm.h` の `#define OPM_CLOCK_MODE OPM_CLOCK_MODE_4MHZ` の行を書き換える
- ヘッダを触らずに再コンフィグする:
  ```bash
  cmake -S . -B build -G Ninja -DCMAKE_BUILD_TYPE=Release -DPICO_BOARD=pico2 -DOPM_CLOCK_MODE=1
  ```
  `-DOPM_CLOCK_MODE=` （空）に戻すと `opm.h` の既定値に従う。

**プリセット外の値を使うときは φM と sys_clk の両方を整数分周になる組で指定すること**
（片方だけの変更は小数分周になり、φM にジッタが乗る）。理由と、整数分周にならなかった
場合の挙動は [docs §2](docs/pico-opm-writer.md#2-φm-の生成) にある。

φM を変えても PCM のサンプリングレート（φM/64）が変わるだけで、タイミング定数の
書き換えは要らない。

## 3. ホストインタフェース

### 3.1 接続

- USB CDC (仮想 COM ポート) **2 ポート**。

  | | 用途 | macOS でのデバイス名の例 |
  | --- | --- | --- |
  | CDC #0 | コマンド。Pico SDK の `stdio_usb` がそのまま使う | `/dev/cu.usbmodem11201` |
  | CDC #1 | PCM データ出力（[§4](#4-pcm-出力)） | `/dev/cu.usbmodem11203` |

  CDC #0 をディスクリプタの先頭に置いているので、コマンド側のデバイス名は 1 ポート構成の
  ときと変わらない。CDC #1 は末尾の番号が増えたものになる。
  2 本は独立しているので、コマンドを打ちながら PCM を取り込める。
- CDC を 2 本にする都合で **`picotool load -fx`（BOOTSEL 不要の書き込み）は使えない**
  （[§6.4](#64-書き込み代替経路)）。
- ボーレート・パリティ等の設定は無視される（USB CDC のため何を指定しても動作する）。
- macOS 例: `screen /dev/cu.usbmodem11201 115200`。
  **`/dev/tty.*` ではなく `/dev/cu.*` を使う**（`tty.*` は DCD 待ちで open がブロックする）。
  デバイス名の引き直し方は [§6.5](#65-シリアル-stdio-の読み取り) を参照。
- 接続を検出した時点で起動バナーを出力する（接続前の出力は捨てられるため）。

### 3.2 行フォーマット

- コマンドは **1 行 1 コマンド**。行末は `LF` / `CR` / `CRLF` のいずれでも受け付ける。
- 1 行の最大長は 255 文字。超えた場合は `ERR too long` を返し、その行を破棄する。
- コマンド文字・16 進数の大文字小文字は区別しない。
- トークン区切りは空白またはタブ（連続可）。
- 空行、および **行頭が `#` の行**はコメントとして無視し、**応答も返さない**。

**行末コメント（`w 20 c7 # ...`）には対応していない。** `#` は引数のトークンとして読まれ、
`ERR bad argument` または `ERR wrong arity` になる。行末コメント・プレースホルダ置換・
キャプチャ制御が要るシーケンスは [tools/opm-writer.py](docs/opm-writer.md) 経由で流し込む。

### 3.3 応答

各コマンドは必ず 1 行の応答で終わる。**例外は空行とコメント行だけ**で、これらは
何も返さない（[§3.2](#32-行フォーマット)）。

| 応答 | 意味 |
| --- | --- |
| `OK` | 正常終了 |
| `ERR <理由>` | エラー |

情報を返すコマンドは、`#` で始まる情報行を 0 行以上出力したあと最後に `OK` を返す。
ホスト側は「`#` 始まりは情報、それ以外の 1 行が終端」と扱えばよい。

情報行は 4 種類ある。いずれも `# ` で始まるので、区別せず読み飛ばしても構わない。

| 情報行 | 意味 |
| --- | --- |
| `# <tag>   : ...` | 通常の情報。`<tag>` は主題（`vgm` / `adpcm` / `capture` など）を表す |
| `# hint    : ...` | **直後の** `ERR` の理由と対処。応答より先に出る。**`ERR wrong state` には必ず付く** |
| `# warn    : ...` | 処理は続いたが注意が要ること |
| `# ERR ...` | コマンドの応答ではない非同期の通知（[§3.18](#318-非同期通知)） |

**ファームウェアの応答はすべて英語。** 例外は `mdx play` / `mdx status` の `# title` 行
だけで、これは MDX ファイル中の Shift_JIS をそのまま流している（[§3.15](#315-mdxmdx-再生)）。

エラー理由の一覧:

| 応答 | 発生条件 |
| --- | --- |
| `ERR unknown command` | 未知のコマンド。1 文字のコマンドか `clock` / `storage` / `vgm` / `mdx` / `autoplay` / `reset` / `help` のいずれでもない場合と、それらのサブコマンドが未知の場合（`clock 5` のような未知のプリセット名も含む） |
| `ERR bad argument` | 引数が 16 進数 / 10 進数として解釈できない、ファイル名が不正、または語の引数が想定外（`mdx pcm maybe` / `storage format no`） |
| `ERR wrong arity` | 引数の個数が合わない |
| `ERR out of range` | 引数が許容範囲外 |
| `ERR too long` | 行が長すぎる |
| `ERR wrong state` | いまの状態では実行できない。**直前に必ず理由を示す `# hint` 行が出る。** どのコマンドがどの状態で拒否されるかは [§3.19](#319-状態による拒否の一覧) にまとめてある |
| `ERR no filesystem` | ストレージが未フォーマット、または領域がファームウェアと重なっている |
| `ERR not found` | 指定したファイルが無い、`/VGM` / `/MDX` が無い、または `autoplay list` を打ったときにプレイリストがまだ作られていない（[§3.17](#317-autoplay自動再生)） |
| `ERR bad file` | VGM / MDX として読めない（マジック不正 / ヘッダが壊れている / gzip ストリームが壊れている / MDX が 64KiB を超える） |
| `ERR io error` | フラッシュまたはファイルシステムの入出力に失敗した |
| `ERR not connected` | CDC #1 が開かれていない状態で `p 1`（[§3.10](#310-ppcm-出力)） |
| `ERR drain timeout` | `p 0` のドレインが 2 秒で終わらなかった（[§3.10](#310-ppcm-出力)） |
| `ERR self test failed` | `t` の自己テストのどれかが失敗した（[§3.12](#312-t自己テスト)） |
| `ERR unsupported` | この構成に機能が無い。`clock` の切り替え先の sys_clk をこのチップで生成できない（[§3.16](#316-clockクロック切り替え)）か、ビルド時に無効化されている（`MDX_ENABLED=0` / `PCM8_ENABLED=0`。[§9.8](#98-無効化)、`AUTOPLAY_ENABLED=0`。[§3.17](#317-autoplay自動再生)） |

### 3.4 コマンド一覧

| コマンド | 書式 | 説明 |
| --- | --- | --- |
| `w` | `w <addr> <data> [<addr> <data> ...]` | レジスタ書き込み。引数は 16 進。addr/data のペアを 1 行に複数並べて連続書き込みできる。**途中でエラーになった場合、そこまでの書き込みは実行済み**のまま `ERR` を返す |
| `r` | `r 0` / `r 1` | A0=0 / A0=1 で 1 バイト読み出し（[§3.21](#321-r読み出し)） |
| `reset` | `reset` | /IC によるハードウェアリセット。I2S のアンダーランを 1 回伴う（[§5.3](#53-アンダーラン)） |
| `c` | `c` | ソフトウェアによる全レジスタクリア（[§3.5](#35-cクリアが書き込む内容)） |
| `d` | `d <ms>` | 指定ミリ秒待機。10 進、`0`-`60000`。待っている間も PCM の送出は続く |
| `p` | `p` / `p 1` / `p 2` / `p 0` | PCM 出力の状態表示 / 開始 / 演奏に連動して開始 / 停止（[§3.10](#310-ppcm-出力)） |
| `s` | `s` / `s 0` | 統計の表示 / リセット（[§3.11](#311-s統計)） |
| `t` | `t` | 自己テスト（[§3.12](#312-t自己テスト)） |
| `i` | `i` | 情報表示（[§3.6](#36-i情報表示の出力例)） |
| `h` | `h` / `?` / `help` | コマンド一覧を表示 |
| `clock` | `clock` / `clock status` / `clock 4` / `clock 3.58` / `clock auto` / `clock fixed` | φM の表示と切り替え（[§3.16](#316-clockクロック切り替え)） |
| `storage` | `storage` / `storage status` / `storage host` / `storage player` / `storage format [force] yes` / `storage trace` | ストレージの状態表示とモード切り替え（[§3.13](#313-storageストレージ)） |
| `vgm` | `vgm` / `vgm status` / `vgm list` / `vgm play <path>` / `vgm stop` / `vgm loop [<n>]` / `vgm fade [<ms>]` | VGM の状態表示・一覧・再生、演奏の終わり方（[§3.14](#314-vgmvgm-再生)） |
| `mdx` | `mdx` / `mdx status` / `mdx list` / `mdx play <path>` / `mdx stop` / `mdx loop [<n>]` / `mdx fade [<ms>]` / `mdx pcm [on\|off]` | MDX の状態表示・一覧・再生、演奏の終わり方、ADPCM ミキシングの表示と切り替え（[§3.15](#315-mdxmdx-再生)） |
| `autoplay` | `autoplay` / `autoplay status` / `autoplay list` / `autoplay start` / `autoplay stop` / `autoplay next` / `autoplay prev` / `autoplay mode <list\|random>` / `autoplay loop <n>` / `autoplay fade <ms>` / `autoplay gap <ms>` / `autoplay source <vgm\|mdx\|both>` | VGM と MDX の自動連続再生（[§3.17](#317-autoplay自動再生)） |

コマンド体系の規則:

- **引数を省くと状態表示になる。** `p` / `clock` / `storage` / `vgm` / `mdx` / `mdx pcm` /
  `vgm loop` / `vgm fade` / `mdx loop` / `mdx fade` / `autoplay` は引数なしで現在の状態を
  返す。`clock status` / `storage status` /
  `vgm status` / `mdx status` / `autoplay status` は引数なしの形と同じ（打ちやすい方を
  使えばよい）。
- **状態を変えるコマンドは、変えたあとの状態を返す。** `p 1` / `p 2` / `p 0` / `storage host` /
  `storage player` / `clock 4` / `mdx pcm on` は変更後の状態を出してから `OK` を返す。
- **「止める」「切り替える」は冪等。** `vgm stop` / `mdx stop` / `autoplay stop` / `p 0` /
  `storage host` / `storage player` / `clock 4` は、既にその状態でも `OK` を返す。スクリプトから
  「いま何が動いているか分からないがとにかく止めたい」を書けるようにするため。
- **再生の開始は切り替えでもある。** `vgm play` / `mdx play` は何かが鳴っていても
  受け付け、走っている方（VGM / MDX のどちらでも）を止めてから始める。曲を変えるのに
  `stop` を先に打つ必要はない。
- **引数の基数は `w` だけ 16 進、他は 10 進。** `w` の 16 進は桁数自由で、値が `0xff`
  以下なら受理する（`w f 1` も `w 0020 00c7` も通る）。`0xff` を超えると
  `ERR out of range`。`d <ms>`（`0`-`60000`）と `p 1` / `p 2` / `p 0` / `s 0` は 10 進。
- **引数の語彙は、1 文字コマンドは数値、複数文字コマンドは語。** 1 文字コマンドは
  打鍵の短さを優先して `r 0` / `r 1` / `p 1` / `p 2` / `p 0` / `s 0` / `d 500` とし、複数文字コマンドは
  `on` / `off` / `auto` / `fixed` / `host` / `player` のように語で書く。
  `p on` のような書き方は受け付けない。
- **大小は区別しない。** 1 文字のコマンドも `clock` / `storage` / `vgm` / `mdx` /
  `autoplay` / `reset` / `help` とそのサブコマンドも同様。
- **自動再生とストレージの操作は、基板上のボタンからも行える。** `autoplay start` /
  `autoplay mode` / `autoplay next` / `autoplay prev` / `storage host` に相当する操作を
  SW1 / SW2 の押し方で選べる（[§3.20](#320-ボタンgp21--gp22)）。ボタン起点の操作は
  `#` で始まる情報行しか出さないので、「1 コマンド 1 応答」（[§3.3](#33-応答)）は崩れない。
- **`vgm play` と `mdx play` のファイル名だけは行の残り全部を 1 引数として受ける**ので、
  空白を含む名前もそのまま書ける（`vgm play BAD NAME.VGM`）。サブフォルダは `/` で
  区切って書く（`vgm play KONAMI/GRADIUS.VGM`）。

1 レジスタ書き込みには約 32µs かかる（最大 3 万回/秒）。内訳は
[docs §3.1](docs/pico-opm-writer.md#31-タイミング定数)。

### 3.5 `c`（クリア）が書き込む内容

/IC リセットに近い状態をソフトウェアで作る。実行順:

1. `0xE0`-`0xFF`（全 32 スロットの D1L/RR）に `0x0F`（D1L = 0 / RR = 15、最速リリース）。
   KEY OFF より前に書くので、直前の音色の RR に関わらず即座に減衰する
2. `0x08` に `0x00`-`0x07` を書き、全 8 チャンネルを KEY OFF
3. `0x60`-`0x7F`（全 32 スロットの TL）に `0x7F`（最小音量）
4. `0x0F` に `0x00`（ノイズ off）
5. `0x14` に `0x00`（タイマ / IRQ 停止）
6. `0x01` に `0x00`（LFO リセット解除）
7. `0x18` に `0x00`（LFO 周波数）
8. `0x19` に **`0x80` → `0x00` の順で 2 回**書き込む。`0x19` は bit7 で書き込み先が切り替わる
   レジスタで、`0x80` が PMD = 0、`0x00` が AMD = 0 の設定になる（PMD 側を消し忘れないため
   両方を書く）
9. `0x1B` に `0x00`（LFO 波形 / CT1・CT2）
10. `0x20`-`0x27` に `0x00`（RL / FB / CONNECT）

### 3.6 `i`（情報表示）の出力例

```
# pico-opm-writer 0.3.0
# phiM    : 4000000 Hz (clkdiv 18 + 0/256)
# sys_clk : 144000000 Hz
# preset  : 4  (vgm auto)
# pins    : D0-D7=GP2-GP9 A0=GP10 /CS=GP11 /WR=GP12 /RD=GP13 /IC=GP14
# pins    : phiM=GP15 /IRQ=GP16
# timing  : t_wr=1us t_addr=5us t_data=18.0us (72 phiM) t_rd=1us
# ym3012  : SO=GP17 phi1=GP18 SH1=GP19 SH2=GP20
# pins    : SW1=GP21 SW2=GP22 (pull-up, active low)
# button  : long 1000 ms  boot none
# capture : ring 16384 bytes (4096 frames) rate 62500 Hz
# i2s     : BCK=GP26 LRCK=GP27 DIN=GP28 (clkdiv 36 + 0/256)
# i2s     : 32fs bck 2000000 Hz rate 62500 Hz latency 1024 frames (16384 us)
# piotest : SKIP (disabled)
# storage : flash 0x040000 + 3836 KiB  cluster 4096 B  sector 512 B
# vgm     : dir /VGM  rate 44100 Hz  budget 500 us
# mdx     : dir /MDX  max 64 KiB  budget 500 us
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
## KiCad design board_pcba/pico-opm-writer_pcba.kicad_pcb

File board_pcba/README.md (part):

# board_pcba — RP2350 / PCM5102A 直載せ基板

JLCPCB の **Economic PCBA** で組み立てる pico-opm-writer の基板。Raspberry Pi Pico 2 と
GY-PCM5102 のモジュールを使わず、RP2350A・PCM5102A・周辺部品を直接実装する。
モジュール側に重複していた電源回路・USB・水晶を基板側へ統合してある。

**ファームウェアのピン割り当ては [README.md](../README.md) §1.1 の接続表と同一。**
`src/opm.h` の `OPM_PIN_*` / `src/ym3012.h` の `YM3012_PIN_*` / `src/button.h` の
`BUTTON_PIN_*` はそのまま使える。

回路図・部品配置・配線・GND ベタまで**一通り完成している**。ERC / DRC ともエラー 0 件（§8）。

## 1. ファイル

| ファイル | 内容 |
| --- | --- |
| `pico-opm-writer_pcba.kicad_sch` | 回路図（A3 1 枚。6 ブロックに区切ってある） |
| `pico-opm-writer_pcba.kicad_pcb` | 基板（46 × 47.5mm / 2 層）。配線・GND ベタまで入っている（§5） |
| `pico-opm-writer_pcba.kicad_dru` | カスタム DRC ルール（ソケット内側の部品を許可する。§5.3） |
| `pico-opm-writer.kicad_sym` | プロジェクト固有シンボル（YM2151 のみ） |
| `abracon_aota-b201610s3r3-101-t.kicad_mod` | インダクタのフットプリント（出典は §6） |
| `rpi_capc1005x50_wide.kicad_mod` | C8 / C10 用のパッド間を広げた 0402（**VREG_LX をパッドの間に通すために必須**。§4.6、出典は §6） |
| `sym-lib-table` / `fp-lib-table` | 上の 2 つをライブラリとして登録する |

シンボル・フットプリントは **YM2151 と上の 2 つの `.kicad_mod` 以外すべて KiCad 10 の標準ライブラリ**。

## 2. 回路の構成

```
USB-C VBUS ─┬─ +5V ─┬─ U4 AMS1117-3.3 ── +3V3   RP2350A / フラッシュ / PCM5102A デジタル
            │       ├─ U5 XC6206P332  ── +3.3VA PCM5102A の AVDD / CPVDD
            │       └─ U6 YM2151 VDD
            └─ C1 10uF + C2 100nF

+3V3 ─ U1 VREG_VIN ─┐ RP2350 内蔵スイッチングレギュレータ
      ─ R9 33Ω ─ VREG_AVDD（C9 4.7uF）
                VREG_LX ─ L1 3.3uH ─ VREG_FB = +1V1 ─ DVDD ×3
```

回路図のブロック分け:

| ブロック | 内容 |
| --- | --- |
| A. USB-C ・ 電源 | J1、CC プルダウン、USB 直列終端、U4 / U5 の 2 系統 LDO |
| B. クロック ・ フラッシュ ・ 起動 | X1、U2、BOOTSEL (SW4)、RESET (SW3) |
| C. RP2350A | U1、デカップリング、内蔵レギュレータの外付け部品 |
| D. YM2151 (OPM) | U6、/CS プルアップ、デカップリング |
| E. PCM5102A ・ 音声出力 | U3、I2S 直列抵抗、チャージポンプ、出力フィルタ、J2 |
| F. ユーザー I/F ・ デバッグ端子 | SW1 / SW2、LED、SWD / UART / DAC プローブ、取付穴 |

ブロック間はネットラベルだけでつないである。ネット名は現行 [board/](../board/) を踏襲し、
I2S のみ PCM5102A のピン名に合わせて `LRCK` としている。

### 2.1 RP2350A ↔ YM2151

[README.md](../README.md) §1.1 の接続表そのまま。

| U1 ピン | GPIO | ネット | U6 ピン |
| --- | --- | --- | --- |
| 4,5,7,8,9,10,12,13 | GP2–GP9 | `D0`–`D7` | 10,12,13,14,15,16,17,18 |
| 14 | GP10 | `A0` | 4 |
| 15 | GP11 | `~{CS}` | 7 |
| 16 | GP12 | `~{WR}` | 5 |
| 17 | GP13 | `~{RD}` | 6 |
| 18 | GP14 | `~{IC}` | 3 |
| 19 | GP15 | `ΦM` | 24 |
| 27 | GP16 | `~{IRQ}` | 2 |
| 28 | GP17 | `SO` | 21 |
| 29 | GP18 | `Φ1` | 23 |
| 31 | GP19 | `SH1` | 20 |
| 32 | GP20 | `SH2` | 19 |

GP21 / GP22 はボタン、GP25 は LED、GP26–GP28 は I2S。GP0 / GP1 は UART ヘッダへ引き出す。
**GP23 / GP24 / GP29 と YM2151 の CT1 / CT2 は未接続。**

### 2.2 PCM5102A

GY-PCM5102 の既定ジャンパ設定をハードワイヤしてある。

| ピン | 接続 |
| --- | --- |
| 1 CPVDD / 8 AVDD | `+3.3VA`（U5 の出力。100nF を各ピンに 1 個ずつ） |
| 20 DVDD | `+3V3`（100nF） |
| 18 LDOO | 内蔵 1.8V LDO の出力。100nF + 10µF で `GND` へ |
| 2 CAPP / 4 CAPM | 2.2µF のフライングキャパシタ |
| 5 VNEG | 2.2µF で `GND` へ |
| 12 SCK | `GND`（内蔵 PLL モード） |
| 16 FMT | `GND`（I2S） |
| 11 FLT | `GND`（Normal latency） |
| 10 DEMP | `GND`（De-emphasis off） |
| 17 XSMT | `+3V3`（soft un-mute） |
| 13 BCK / 15 LRCK / 14 DIN | 22Ω 直列で GP26 / GP27 / GP28 |
| 6 OUTL / 7 OUTR | 470Ω → J2.T / J2.R、各々 2.2nF で `GND` へ |

**CPVDD はチャージポンプの電源で、TI のデータシートは AVDD と同じアナログ 3.3V に置く**
（§10.1.1 の Figure 33、§11.1 の Table 12）。デジタル側から取ると、チャージポンプの
パルス電流がアナログ電源へ回り込む。

**470Ω + 2.2nF は TI のデータシートが指定するポストフィルタ**（fc ≈ 154kHz）。
TI は THD+N・SNR・チャンネルセパレーションの規格値をすべて
「10kΩ 負荷 + 470Ω 出力抵抗 + 2.2nF シャント」の条件で規定しているので省略しない。
出力はチャージポンプで GND センターになるため DC カットのコンデンサは要らない。

### 2.3 YM2151 の /CS プルアップ

**R11: `~{CS}` → `+3V3` に 1kΩ。** 電源投入から `opm_init()` が /CS を H にするまでの間、
RP2350 のパッドは入力＋内部プルダウンなので、これが無いと OPM が D0-D7 を駆動する窓ができる
（[README.md](../README.md) §1.3）。

プルアップ先を 5V ではなく **3.3V** にした理由:

- **YM2151 の全入力の VIH は min 2.0V**（TTL しきい値。VIL は max 0.8V、入力リークは
  Vi=10V で 0.1µA 以下）。**RP2350 の内部プルダウンは IOVDD=3.3V で 36kΩ〜113kΩ。**
- この 2 つから、`opm_init()` 前の /CS 電位は次のようになる。

  | プルアップ | R_PD=36k | R_PD=113k | VIH 2.0V への余裕 | /CS Low 時の吸い込み | GP11 の最大電圧 |
  | --- | --- | --- | --- | --- | --- |
  | +5V / 10kΩ | 3.91V | 4.59V | +1.9V | 0.5mA | **4.59V** |
  | +3V3 / 10kΩ | 2.58V | 3.03V | +0.58V | 0.33mA | 3.3V |
  | **+3V3 / 1kΩ** | **3.21V** | **3.27V** | **+1.2V** | 3.3mA | 3.3V |

- 通常動作では GP11 が 3.3V で /CS を駆動するので、5V にしても H レベルは良くならない。
  1kΩ なら起動直後も**通常駆動時と同じ電位**になる。
- 5V プルアップは、VBUS が立って 3.3V がまだ立ち上がり切っていない間、IOVDD 不足のまま
  GP11 へ 5V を流し込む。3.3V なら GP11 は 3.3V レールに追従するだけで IOVDD を超えない。
- 1kΩ は他でも使っているので部品番号が増えない。3.3mA は RP2350 の 1 ピンあたりの駆動能力
  （12mA）にも合計値（`I_IOVSS_MAX` 100mA）にも収まり、/CS が L になるのは
  バスサイクル中だけなので平均消費は無視できる。

3.3V レールの立ち上がり中の短い窓は塞げないが、それは現行 [board/](../board/) と同じ状態で、
README §1.3 の整理がそのまま当てはまる。POR 解除から `opm_init()` までの長いほうの窓は塞げる。

## 3. 部品表

単価は JLCPCB の 10 個購入時。**Basic は Extended 手数料（部品番号ごとに $3）がかからない。**

| Ref | 部品 | LCSC | 種別 | 個数 | 単価 | 小計 |
| --- | --- | --- | --- | ---: | ---: | ---: |
| U1 | RP2350A (A4 ステッピング) | C42411118 | Ext | 1 | $1.2699 | $1.270 |
| U2 | W25Q128JVSIQ (16MB) | C97521 | **Basic** | 1 | $2.2528 | $2.253 |
| U3 | PCM5102APWR | C107671 | Ext | 1 | $1.2440 | $1.244 |
| U4 | AMS1117-3.3 (デジタル) | C6186 | **Basic** | 1 | $0.2161 | $0.216 |
| U5 | XC6206P332MR-G (アナログ) | C5446 | **Basic** | 1 | $0.1449 | $0.145 |
| X1 | ABM8-272-T3 12MHz | C20625731 | Ext | 1 | $0.4217 | $0.422 |
| L1 | AOTA-B201610S3R3-101-T 3.3µH | C42411119 | Ext | 1 | $0.2834 | $0.283 |
| J1 | USB-C 16P | C2765186 | Ext | 1 | $0.0740 | $0.074 |
| SW1–SW4 | TS-1088-AR02016 | C720477 | **Basic** | 4 | $0.0555 | $0.222 |
| D1 | LED 0603 赤 | C2286 | **Basic** | 1 | $0.0074 | $0.007 |
| R2–R4, R10, R11 | 1kΩ 0402 | C11702 | **Basic** | 5 | $0.0039 | $0.019 |
| R5, R6 | 27Ω 0402 | C25100 | Ext | 2 | $0.0032 | $0.006 |
| R7, R8 | 5.1kΩ 0402 | C25905 | **Basic** | 2 | $0.0026 | $0.005 |
| R9 | 33Ω 0402 | C25105 | **Basic** | 1 | $0.0077 | $0.008 |
| R12–R14 | 22Ω 0402 | C25092 | **Basic** | 3 | $0.0057 | $0.017 |
| R15, R16 | 470Ω 0402 | C25117 | **Basic** | 2 | $0.0048 | $0.010 |
| C2, C4, C5, C7, C11–C21, C24–C27, C29, C30 | 100nF 0402 X7R | C1525 | **Basic** | 21 | $0.0055 | $0.115 |
| C22, C23 | 15pF 0402 C0G | C1548 | **Basic** | 2 | $0.0041 | $0.008 |
| C33, C34 | 2.2nF 0402 | C1531 | Ext | 2 | $0.0037 | $0.007 |
| C8–C10 | 4.7µF 0402 6.3V | C23733 | **Basic** | 3 | $0.0232 | $0.070 |
| C31, C32 | 2.2µF 0603 16V | C23630 | **Basic** | 2 | $0.0193 | $0.039 |
| C6, C28 | 10µF 0603 10V | C19702 | **Basic** | 2 | $0.0349 | $0.070 |
| C1, C3 | 10µF 0805 25V | C15850 | **Basic** | 2 | $0.0959 | $0.192 |

**実装 62 点で $6.70 / 枚。Extended は 7 種（U1 / U3 / X1 / L1 / J1 / 27Ω / 2.2nF）で
手数料 $21。10 枚なら部品 $67.0 + $21 = 約 $88**（PCB 製造費・実装費・送料は別）。

R1（10kΩ・QSPI_SS のプルアップ）は **DNF**。フットプリントだけ用意してある（§4.4）。

### 3.1 手はんだする部品（PCBA 対象外）

| Ref | 部品 | フットプリント |
| --- | --- | --- |
| U6 | YM2151 + DIP-24 ソケット | `Package_DIP:DIP-24_W15.24mm_Socket` |
| J2 | ST-005-G 3.5mm ステレオジャック | `Connector_Audio:Jack_3.5mm_Switronic_ST-005-G_horizontal` |
| J3 | SWD 1×3 ピンヘッダ | `Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical` |
| H1 / H2 | M2 取付穴（対角 2 箇所） | `MountingHole:MountingHole_2.2mm_M2` |

| ヘッダ | ピン |
| --- | --- |
| J3 (SWD) | 1=`SWDIO` / 2=`GND` / 3=`SWCLK` |

### 3.2 未使用の GPIO

**GP0 / GP1（UART）は未接続。** 当初は φ1.0mm のテストパッドを置いていたが、基板を
縮めるにあたって削除した。回路図では U1 の GPIO0 / GPIO1 に no-connect フラグを
付けてあるので ERC は 0 件になる。

`Φ1` / `SO` / `SH1` / `SH2` の観測が要るときは、U1 と U6 の間の配線にプローブを当てる。

## 4. 部品選定：検討した選択肢と選定理由

### 4.1 サイズと価格

| 項目 | 選択肢 | 採用 | 理由 |
| --- | --- | --- | --- |
| チップ抵抗 | 0402 / 0603 | **0402 に統一** | Economic PCBA の最小サイズが 0402 |
| µF 級コンデンサ | 全部 0402 / 全部 0603 / 電圧で使い分け | **電圧で使い分け** | 0402 の Basic 品は 6.3V しかなく DC バイアスで大きく容量が減る。`+5V` と `+3V3` の 10µF は 0805/25V、`+3.3VA` と LDOO の 10µF は 0603/10V |
| VREG 周辺の 4.7µF | 0402 / 0603 | **0402** | RPi の設計ガイド §2.1 が 0402 (1005 metric) を指定。レギュレータのレイアウトが critical なのでサイズを勝手に大きくしない |
| タクトスイッチ | 5.1×5.1mm / 3.9×3×2mm | **C720477 (3.9×3×2mm)** | Basic かつ在庫 90 万個。KiCad 標準 `SW_SPST_TS-1088-xR020` がこの部品のデータシートから起こされている |

### 4.2 フラッシュ容量

| 選択肢 | 判断 |
| --- | --- |
| 2MB (W25Q16) | 曲データが約 1.7MB までで足りない |

Parts:
C1, C3: 10uF; C_0805_2012Metric; LCSC Part # C15850
C2, C4, C5, C7, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C24, C25, C26, C27, C29, C30: 100nF; C_0402_1005Metric; LCSC Part # C1525
C6, C28: 10uF; C_0603_1608Metric; LCSC Part # C19702
C8, C10: 4.7uF; rpi_capc1005x50_wide; LCSC Part # C23733
C9: 4.7uF; C_0402_1005Metric; LCSC Part # C23733
C22, C23: 15pF; C_0402_1005Metric; LCSC Part # C1548
C31, C32: 2.2uF; C_0603_1608Metric; LCSC Part # C23630
C33, C34: 2.2nF; C_0402_1005Metric; LCSC Part # C1531
D1: LED; LED_0603_1608Metric; LCSC Part # C2286
H1, H2: MountingHole; MountingHole_2.2mm_M2
J1: USB-C 16P; USB_C_Receptacle_Palconn_UTC16-G; LCSC Part # C2765186
J2: ST-005-G; Jack_3.5mm_Switronic_ST-005-G_horizontal; not fitted
J3: SWD; PinHeader_1x03_P2.54mm_Vertical; not fitted
L1: 3.3uH; abracon_aota-b201610s3r3-101-t; LCSC Part # C42411119
R1: 10k; R_0402_1005Metric; LCSC Part # C25744; not fitted
R2, R3, R4, R10, R11: 1k; R_0402_1005Metric; LCSC Part # C11702
R5, R6: 27; R_0402_1005Metric; LCSC Part # C25100
R7, R8: 5.1k; R_0402_1005Metric; LCSC Part # C25905
R9: 33; R_0402_1005Metric; LCSC Part # C25105
R12, R13, R14: 22; R_0402_1005Metric; LCSC Part # C25092
R15, R16: 470; R_0402_1005Metric; LCSC Part # C25117
SW1, SW2, SW3, SW4: SW_Push; SW_SPST_TS-1088-xR020; LCSC Part # C720477
U1: RP2350A; QFN-60-1EP_7x7mm_P0.4mm_EP3.4x3.4mm; LCSC Part # C42411118
U2: W25Q128JVSIQ; SOIC-8_5.3x5.3mm_P1.27mm; LCSC Part # C97521
U3: PCM5102A; TSSOP-20_4.4x6.5mm_P0.65mm; LCSC Part # C107671
U4: AMS1117-3.3; SOT-223-3_TabPin2; LCSC Part # C6186
U5: XC6206P332MR; SOT-23-3; LCSC Part # C5446
U6: YM2151; DIP-24_W15.24mm_Socket; not fitted
X1: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC Part # C20625731

Connections:
+3.3VA: C6.1, C7.1, C29.1, C30.1, U3.1 (CPVDD), U3.8 (AVDD), U5.2 (VO)
+3V3: C3.1, C4.1, C8.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C24.1, C26.1, R1.1, R9.1, R11.1, U1.1 (IOVDD), U1.11 (IOVDD), U1.20 (IOVDD), U1.30 (IOVDD), U1.38 (IOVDD), U1.44 (ADC_AVDD), U1.45 (IOVDD), U1.49 (VREG_VIN), U1.53 (USB_OTP_VDD), U1.54 (QSPI_IOVDD), U2.8 (VCC), U3.17 (XSMT), U3.20 (DVDD), U4.2 (VO)
/A0: U1.14 (GPIO10), U6.4 (A_{0})
/BCK: R12.1, U1.40 (GPIO26/ADC0)
/BUTTON1: SW1.1, U1.33 (GPIO21)
/BUTTON2: SW2.1, U1.34 (GPIO22)
/D0: U1.4 (GPIO2), U6.10 (D_{0})
/D1: U1.5 (GPIO3), U6.12 (D_{1})
/D2: U1.7 (GPIO4), U6.13 (D_{2})
/D3: U1.8 (GPIO5), U6.14 (D_{3})
/D4: U1.9 (GPIO6), U6.15 (D_{4})
/D5: U1.10 (GPIO7), U6.16 (D_{5})
/D6: U1.12 (GPIO8), U6.17 (D_{6})
/D7: U1.13 (GPIO9), U6.18 (D_{7})
/DIN: R14.1, U1.42 (GPIO28/ADC2)
/LED: R10.1, U1.37 (GPIO25)
/LRCK: R13.1, U1.41 (GPIO27/ADC1)
/QSPI_SCLK: U1.56 (QSPI_SCLK), U2.6 (CLK)
/QSPI_SD0: U1.57 (QSPI_SD0), U2.5 (DI/IO_{0})
/QSPI_SD1: U1.59 (QSPI_SD1), U2.2 (DO/IO_{1})
/QSPI_SD2: U1.58 (QSPI_SD2), U2.3 (~WP/IO_{2})
/QSPI_SD3: U1.55 (QSPI_SD3), U2.7 (~HOLD/~RESET/IO_{3})
/QSPI_SS: R1.2, R2.1, U1.60 (~QSPI_SS), U2.1 (~CS)
/RUN: R3.1, U1.26 (RUN)
/SH1: U1.31 (GPIO19), U6.20 (SH1)
/SH2: U1.32 (GPIO20), U6.19 (SH2)
/SO: U1.28 (GPIO17), U6.21 (SO)
/SWCLK: J3.3, U1.24 (SWCLK)
/SWDIO: J3.1, U1.25 (SWDIO)
/USB_DM: R6.2, U1.51 (USB_DM)
/USB_DP: R5.2, U1.52 (USB_DP)
/VREG_LX: L1.1, U1.48 (VREG_LX)
/XIN: C22.1, U1.21 (XIN), X1.1
/XOUT: R4.2, U1.22 (XOUT)
/~CS: R11.2, U1.15 (GPIO11), U6.7 (~CS)
/~IC: U1.18 (GPIO14), U6.3 (~IC)
/~IRQ: U1.27 (GPIO16), U6.2 (~IRQ)
/~RD: U1.17 (GPIO13), U6.6 (~RD)
/~WR: U1.16 (GPIO12), U6.5 (~WR)
/Φ1: U1.29 (GPIO18), U6.23 (Φ1)
/ΦM: U1.19 (GPIO15), U6.24 (ΦM)
unnamed: C23.1, R4.1, X1.3
unnamed: C33.2, J2.T, R15.2
unnamed: C34.1, J2.R, R16.2
unnamed: D1.2 (A), R10.2
unnamed: J1.A5 (CC1), R7.1
unnamed: J1.B5 (CC2), R8.1
unnamed: J1.A6 (D+), J1.B6 (D+), R5.1
unnamed: J1.A7 (D-), J1.B7 (D-), R6.1
unnamed: R2.2, SW4.1
unnamed: R3.2, SW3.1
unnamed: R12.2, U3.13 (BCK)
unnamed: C31.2, U3.4 (CAPM)
unnamed: C31.1, U3.2 (CAPP)
unnamed: R14.2, U3.14 (DIN)
unnamed: C27.1, C28.1, U3.18 (LDOO)
unnamed: R13.2, U3.15 (LRCK)
unnamed: R15.1, U3.6 (OUTL)
unnamed: R16.1, U3.7 (OUTR)
unnamed: C32.1, U3.5 (VNEG)

Notes on the sheet:
電源フラグ（ERC 用）
H1 / H2 = M2 取付穴（対角 2 箇所）
+3V3 : RP2350A / U2 フラッシュ / U3 DVDD・XSMT
470Ω + 2.2nF = TI 推奨ポストフィルタ (fc≈154kHz)
E. PCM5102A ・ 音声出力
→ U6 YM2151 VDD
DNF（RPi ガイド §3.1）
C8 = VREG_VIN
電源ツリー
SCK=GND（内蔵 PLL）/ FLT=GND
+1V1 : U1 内蔵バックの出力 (DVDD ×3)
内蔵スイッチングレギュレータ（RPi ガイド §2.1 の部品選定に従う）
C. RP2350A
CT1 / CT2 は未使用（README §1.2）
IOVDD ×6 / ADC_AVDD / USB_OTP_VDD + QSPI_IOVDD / フラッシュ
AVDD 専用。RP2350 内蔵バックのノイズを分離する
F. ユーザー I/F ・ デバッグ端子
（YM2151 の VIH は 2.0V。GP11 に 5V を掛けないため +3V3 へ引く）
15pF ×2 → 直列 7.5pF + 寄生 3pF ≒ CL 10pF
B. クロック ・ フラッシュ ・ 起動
DEMP=GND / FMT=GND（I2S）
DVDD ×3（内蔵バックの出力）
USB-C VBUS = +5V → U4 AMS1117-3.3 → +3V3
+3.3VA : U3 AVDD + CPVDD
SW4 = BOOTSEL SW3 = RESET
D. YM2151 (OPM)
起動直後 GPIO は入力＋内部プルダウン。1k なら /CS は 3.2V 以上を保つ
A. USB-C ・ 電源
J3 と U6・J2 は PCBA では実装しない（手はんだ）
→ U5 XC6206P332 → +3.3VA
XSMT=+3V3（un-mute）
GP0 / GP1 (UART) は未使用
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

Board: 2 copper layers, 46.0 x 47.5 mm, 68 parts (0 on the bottom side), 64 nets.

## KiCad design board/pico-opm-writer.kicad_pcb

Parts:
A1: RaspberryPi_Pico; RPi_Pico_SMD
A2: GY-PCM5102; GY-PCM5102_BOARD
C1: 0.1uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J3: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
SW1, SW2, SW3: SW_Push; SW_PUSH_6mm_H7.3mm
U1: YM2151; DIP-24_W15.24mm_Socket

Connections:
+5V: A1.40 (VBUS), A2.6 (VIN), C1.1, U1.22 (V_{DD})
/A0: A1.14 (GPIO10), U1.4 (A_{0})
/BCK: A1.31 (GPIO26_ADC0), A2.2 (BCK)
/BUTTON1: A1.27 (GPIO21), SW1.1
/BUTTON2: A1.29 (GPIO22), SW2.1
/D0: A1.4 (GPIO2), U1.10 (D_{0})
/D1: A1.5 (GPIO3), U1.12 (D_{1})
/D2: A1.6 (GPIO4), U1.13 (D_{2})
/D3: A1.7 (GPIO5), U1.14 (D_{3})
/D4: A1.9 (GPIO6), U1.15 (D_{4})
/D5: A1.10 (GPIO7), U1.16 (D_{5})
/D6: A1.11 (GPIO8), U1.17 (D_{6})
/D7: A1.12 (GPIO9), U1.18 (D_{7})
/DIN: A1.34 (GPIO28_ADC2), A2.3 (DIN)
/LCK: A1.32 (GPIO27_ADC1), A2.4 (LCK)
/RUN: A1.30 (RUN), SW3.1
/RX: A1.2 (GPIO1), J2.2
/SH1: A1.25 (GPIO19), J3.4, U1.20 (SH1)
/SH2: A1.26 (GPIO20), J3.5, U1.19 (SH2)
/SO: A1.22 (GPIO17), J3.3, U1.21 (SO)
/SWCLK: A1.D1 (SWCLK), J1.3
/SWDIO: A1.D3 (SWDIO), J1.1
/TX: A1.1 (GPIO0), J2.1
/~CS: A1.15 (GPIO11), U1.7 (~CS)
/~IC: A1.19 (GPIO14), U1.3 (~IC)
/~IRQ: A1.21 (GPIO16), U1.2 (~IRQ)
/~RD: A1.17 (GPIO13), U1.6 (~RD)
/~WR: A1.16 (GPIO12), U1.5 (~WR)
/Φ1: A1.24 (GPIO18), J3.2, U1.23 (Φ1)
/ΦM: A1.20 (GPIO15), U1.24 (ΦM)
GND: A1.3 (GND), A1.8 (GND), A1.13 (GND), A1.18 (GND), A1.23 (GND), A1.28 (GND), A1.33 (AGND), A1.38 (GND), A1.D2 (GND), A2.1 (SCK), A2.5 (GND), C1.2, J1.2, J2.3, J3.1, SW1.2, SW2.2, SW3.2, U1.1 (GND), U1.11 (GND)

Board: 2 copper layers, 74.0 x 54.0 mm, 14 parts (0 on the bottom side), 31 nets.

Notices in the files:
README.md:
MIT License。詳細は [LICENSE](LICENSE) を参照。
（(c)1988-92 milk., K.MAEKAWA, Missy.M, Yatsube）の仕様に準拠している。
board_pcba/README.md:
Raspberry Pi の `RPI-RP2350A-MINIMAL_R4-S1`（`reference/board/` に同梱、**MIT License**、
Copyright (c) 2026 Raspberry Pi Ltd）の `.kicad_pcb` に埋め込まれていたフットプリント
